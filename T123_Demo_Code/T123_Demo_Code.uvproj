# Keil uVision project T123_Demo_Code.uvproj, settings and files
target T123_Demo_Code (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: T123_Demo_Code +hex
  AfterMake: .\Object\Hex2BinBatch_64_lx51.bat T123_Demo_Code 49152
  c flags: Optimize=8 SizeSpeed=1
  c define: T123AI
  c include: .\IncludeFile;..\tw_lib\sys;..\tw_lib\drivers
  link misc: REMOVEUNUSED
  group Common
    ./SourceFile/: STARTUP.A51 c_root.c timer.c interrupt.c check_event.c version.c
    ../tw_lib/sys/: BANK_SWITCH.A51
  group Sys
    ../tw_lib/sys/: tw_irq.c get_eq.c iccontrol.c
  group Drivers
    ../tw_lib/drivers/: spirw.c spiosd.c osd2api.c cq.c serial.c tw_timer.c doprnt.c rc.c i51_i2c_drivers.c sarkey.c i51_i2c_gpio.c gpio.c
    ./SourceFile/: nvp6124_drv.c video.c
  group tw_widget_sys
    ../tw_lib/sys/: tw_widget_sys.c
    ./i51/: page_handler.c
  group Init
    ../tw_lib/sys/: tw_init.c
    ./SourceFile/: init.c panel.c
    ../tw_lib/drivers/: videodetect.c
  group Doc
    ./: Releas Note.txt
  group main page
    ./i51/: page_RGB.c page_RGB_struct.c
